# Repository aragig/pedal_blender

## KiCad design Jacks Interface/Jacks Interface.kicad_pcb

Parts:
J1: To board GND; Header_Pin_1p_Large_GND
J2: INPUT; Jack_6.35mm_Neutrik_6P
J4: To board IN; Header_Pin_1p_Large_IN
J5: To SW GND; Header_Pin_1p_Large_GND
J6: To board OUT; Header_Pin_1p_Large_OUT
J7: OUTPUT; Jack_6.35mm_Neutrik_6P
J8: SEND; Jack_6.35mm_Neutrik_6P
J11: To board RETURN; Header_Pin_1p_Large
J12: RETURN; Jack_6.35mm_Neutrik_6P
J13: EARTH; Header_Pin_1p_Large_GND

Connections:
GND: J1.1, J2.S, J2.SN, J7.R, J7.RN, J7.S, J7.SN, J8.R, J8.RN, J8.S, J8.SN, J12.R, J12.RN, J12.S, J12.SN, J13.1
unnamed: J2.R, J5.1
unnamed: J2.T, J4.1, J8.T
unnamed: J6.1, J7.T
unnamed: J11.1, J12.T

Board: 2 copper layers, 100.6 x 33.7 mm, 10 parts (0 on the bottom side), 5 nets.

## KiCad design BLENDER V2.0.kicad_pcb

Parts:
C1: 0.1u; C_Poly_5mm
C2: 0.1u; C_Poly_8mm
C3: 22u; CP_5mm
C4, C5: 2.2u; CP_5mm
C6: 47u; CP_5mm
J1: +9V; Header_Pin_1p_Large
J2: GND; Header_Pin_1p_Large
J3: SEND; Header_Pin_1p_Large
J4: IN; Header_Pin_1p_Large
J5: RETURN; Header_Pin_1p_Large
J6: TO VOLUME POT; Header_Pin_1p_Large
J7: OUT; Header_Pin_1p_Large
JP1: Jumper_2_Bridged; C_Poly_5mm
Q1: 2SK303; FET_GSD2
R1, R4: 1M; R_Normal
R2, R3: 12k; R_Normal
R5: 3k3; R_Normal
R6, R7, R8, R9, R10, R12, R14: 10k; R_Normal
R11: 20k; R_Normal
R13: 4.7K; R_Normal
R15: 680; R_Normal
RV1: 10kB; POT_ON_BOARD_REVERSE
RV2: 50kB; POT_ON_BOARD_REVERSE
U1: NJM5532; DIP-8

Connections:
+9V: C1.1, J1.1, Q1.3 (D), R2.1, U1.8 (V+)
GND: C1.2, C3.2, J2.1, R1.2, R3.2, R5.2, RV2.1, U1.4 (V-)
unnamed: C2.1, J3.1, J4.1, R1.1
unnamed: C2.2, Q1.1 (G), R4.1
unnamed: C3.1, R2.2, R3.1, R4.2, R10.1, R13.2, RV1.2
unnamed: C4.1, JP1.1 (A)
unnamed: C4.2, Q1.2 (S), R5.1
unnamed: C5.1, R7.1
unnamed: C5.2, J5.1
unnamed: C6.1, R15.2
unnamed: C6.2, J6.1, RV2.3
unnamed: J7.1, RV2.2
unnamed: JP1.2 (B), R6.1
unnamed: R6.2, R9.1, RV1.3
unnamed: R7.2, R8.1, RV1.1
unnamed: R10.2, U1.3 (+)
unnamed: R8.2, R9.2, R11.1, U1.2 (-)
unnamed: R11.2, R12.1, U1.1
unnamed: R12.2, R14.1, U1.6 (-)
unnamed: R13.1, U1.5 (+)
unnamed: R14.2, R15.1, U1.7

Notes on the sheet:
BLEND
コンデンサー前に1M入れたい
MASTER

Board: 2 copper layers, 43.2 x 41.0 mm, 30 parts (0 on the bottom side), 20 nets.

## KiCad design BLENDER V2.1.kicad_pcb

Parts:
C1: 0.1u; C_Poly_5mm
C2, C3: 0.1u; C_Poly_8mm
C4, C5: 2.2u; CP_5mm
C6: 47u; CP_5mm
J1: 9V; Header_Pin_1p_Large
J2: GND; Header_Pin_1p_Large
J3: Virtual GND; Header_Pin_1p_Large
J5: IN; Header_Pin_1p_Large
J6: RETURN; Header_Pin_1p_Large
J7: OUT; Header_Pin_1p_Large
POT1: 10k; Header_Pin_3p
Q1, Q2: 2SK303; FET_GSD
R1, R2, R3, R4: 1M; R_Normal
R5, R6: 3k3; R_Normal
R7, R8, R9, R10, R11, R13, R15: 10k; R_Normal
R12: 20k; R_Normal
R14: 4.7K; R_Normal
R16: 680; R_Normal
U1: NJM5532; DIP-8

Connections:
+9V: C1.1, J1.1, Q1.3 (D), Q2.3 (D), U1.8 (V+)
GND: C1.2, J2.1, R1.2, R2.2, R5.2, R6.2, U1.4 (V-)
unnamed: C2.2, Q1.1 (G), R3.1
unnamed: C3.1, J6.1, R2.1
unnamed: C3.2, Q2.1 (G), R4.1
unnamed: C4.1, R8.1
unnamed: C4.2, Q2.2 (S), R6.1
unnamed: C5.1, R7.1
unnamed: C5.2, Q1.2 (S), R5.1
unnamed: C6.1, R16.2
unnamed: C6.2, J7.1
unnamed: POT1.1, R8.2, R9.1
unnamed: POT1.3, R7.2, R10.1
unnamed: R9.2, R10.2, R12.1, U1.2 (-)
unnamed: R11.2, U1.3 (+)
unnamed: R12.2, R13.1, U1.1
unnamed: R13.2, R15.1, U1.6 (-)
unnamed: R14.1, U1.5 (+)
unnamed: R15.2, R16.1, U1.7
SEND: C2.1, J5.1, R1.1
VGND: J3.1, POT1.2, R3.2, R4.2, R11.1, R14.2

Notes on the sheet:
BLEND
エフェクトOUTのみPOTを通す
バッファがないとエフェクター先でバイパスされた時に短絡して原音に影響してしまう しかしBLENDERを使うときにエフェクタ先でバイパスにすることは無いはず

Board: 2 copper layers, 49.3 x 43.0 mm, 32 parts (0 on the bottom side), 21 nets.

## KiCad design BLENDER V1.1.kicad_pcb

Board: 2 copper layers, 43.2 x 32.5 mm, 31 parts (0 on the bottom side), 17 nets.

Parts:
C1, C4, C7: 0.1u; C_Poly_5mm
C2, C3, C5, C6, C8: 10u; CP_5mm
J1: 9V; Header_Pin_1p
J2: GND; Header_Pin_1p
J3: IN; Header_Pin_1p
J4: SEND INVERSION; Header_Pin_1p
J5: SEND NON-INVERTING; Header_Pin_1p
J6: MIXED OUT; Header_Pin_1p
J7: FROM POT; Header_Pin_1p
Q1: 2SK303; FET_GSD
R1, R2: 10k; R_Normal
R3, R4: 2M2; R_Normal
R5, R8, R9, R11, R14: 100k; R_Normal
R6, R10: 680; R_Normal
R7: 47k; R_Normal
R12: 1M; R_Normal
R13: 3k3; R_Normal
U1: TL072; DIP-8

Connections:
+9V: C1.1, C2.1, J1.1, Q1.3 (D), R1.1, U1.8 (V+)
GND: C1.2, C3.2, J2.1, R2.2, R3.2, R9.2, R11.2, R13.2, R14.2, U1.4 (V-)
unnamed: C2.2, C3.1, R1.2, R2.1, R4.2, R7.2, R12.2
unnamed: C4.1, J3.1, R3.1
unnamed: C4.2, R4.1, U1.3 (+)
unnamed: C5.1, R6.2
unnamed: C5.2, J5.1, R9.1
unnamed: C6.1, R10.2
unnamed: C6.2, J4.1, R11.1
unnamed: C8.2, J6.1, R14.1
unnamed: C7.2, Q1.1 (G), R12.1
unnamed: C8.1, Q1.2 (S), R13.1
unnamed: R5.1, R6.1, U1.1, U1.2 (-)
unnamed: R7.1, U1.5 (+)
unnamed: R5.2, R8.1, U1.6 (-)
unnamed: R8.2, R10.1, U1.7
unnamed: C7.1, J7.1

## Commit log

2023-10-25 v1.1
2023-10-25 v1.2
2023-10-25 v2.0
2023-10-25 v2.1
2023-11-03 sketchの追加
2023-11-03 追加: jack interface
2024-05-01 fix: 回路の修正
2024-06-21 fix: jack interface修正
